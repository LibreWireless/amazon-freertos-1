# IAR project aws_demos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F779AI ST STM32F779AI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: UNITY_INCLUDE_CONFIG_H; AMAZON_FREERTOS_ENABLE_UNIT_TESTS; AUDIOPLAYER_TWOLIST; COMPRESSION_ENABLED; HTTP2_IMPROVEMENTS; LIBRE_EVB_ENABLED; __LIBRE_EVK_ENABLED; LIBRE_INIT; LIBRE_PORT; __LITEOS_VER__=7; __LPSDRAM_16MB; LWIP_DEBUG; LWIP_DNS_EXT; LWIP_NETIF_API; LWIP_SO_RCVTIMEO; LWIP_SO_SNDTIMEO; __MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; MHD_DEBUG; MHD_SUPPORT_WL_CMD; MHD_USE_POLLING_MODE; MHD_WL_COUNTERS; NEW_MULTIPART_PARSER; NTP_POOL_ENABLE; RESAMPLER_ENABLED; STM32F779xx; USE_DHCP; USE_HAL_DRIVER; USE_IOEXPANDER; USE_STM32F769I_EVAL; _7ZIP_ST; ssize_t=int; BUILDCFG; DEBUG_VERSION=0; WL_CMD; __UNITY_EXCLUDE_SETJMP_H
  ICCARM.PreInclude: ..\..\..\..\..\vendors\libre\mavid\components\Inc\BuildConfig.h
  ICCARM.CCIncludePath2: ..\..\..\..\..\vendors\libre\mavid\components\CMSIS_RTOS; ..\..\..\..\..\vendors\libre\mavid\components\lzma; ..\..\..\..\..\vendors\libre\mavid\components\APP\lib\janson\inc; ..\..\..\..\..\libraries\abstractions\wifi\include; ..\..\..\..\..\vendors\libre\mavid\components\LwIP\system; ..\..\..\..\..\vendors\libre\mavid\components\Inc; ..\..\..\..\..\vendors\libre\mavid\components\LwIP\src\include; ..\..\..\..\..\vendors\libre\mavid\components\APP; ..\..\..\..\..\vendors\libre\mavid\BSP\STM32F769I_EVAL; ..\..\..\..\..\vendors\libre\mavid\components\WiFi\WiFi_Include; ..\..\..\..\..\libraries\abstractions\wifi\include; ..\..\..\..\..\libraries\abstractions\secure_sockets\include; ..\..\..\..\..\libraries\abstractions\wifi\test; ..\..\..\..\..\libraries\abstractions\wifi\include; ..\..\..\..\..\vendors\libre\boards\mavid\aws_demos\config_files; ..\..\..\..\..\libraries\abstractions\platform\include; ..\..\..\..\..\libraries\abstractions\platform\freertos\include; ..\..\..\..\..\libraries\c_sdk\standard\common\include\private; ..\..\..\..\..\libraries\c_sdk\standard\common\include; ..\..\..\..\..\libraries\3rdparty\unity\src; ..\..\..\..\..\libraries\3rdparty\unity\extras\fixture\src; ..\..\..\..\..\freertos_kernel\include; ..\..\..\..\..\freertos_kernel\portable\IAR\ARM_CM7\r0p1; ..\..\..\..\..\demos\include; ..\..\..\..\..\tests\include; ..\..\..\..\..\vendors\libre\mavid\CMSIS\device; ..\..\..\..\..\vendors\libre\mavid\CMSIS\core; ..\..\..\..\..\vendors\libre\mavid\HAL_Driver\Inc; ..\..\..\..\..\libraries\abstractions\wifi\test; ..\..\..\..\..\libraries\abstractions\wifi\include; ..\..\..\..\..\libraries\abstractions\platform\include; ..\..\..\..\..\libraries\abstractions\platform\freertos\include; ..\..\..\..\..\libraries\c_sdk\standard\common\include\private; ..\..\..\..\..\libraries\c_sdk\standard\common\include; ..\..\..\..\..\vendors\libre\mavid\components\APP\lib; ..\..\..\..\..\vendors\libre\mavid\CMSIS\Include; ..\..\..\..\..\vendors\libre\mavid\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\..\libraries\3rdparty\unity\src; ..\..\..\..\..\libraries\freertos_plus\standard\tls\include; ..\..\..\..\..\libraries\freertos_plus\standard\crypto\include; ..\..\..\..\..\libraries\freertos_plus\standard\pkcs11\include; ..\..\..\..\..\libraries\freertos_plus\standard\utils\include; ..\..\..\..\..\libraries\3rdparty\pkcs11; ..\..\..\..\..\libraries\abstractions\pkcs11\mbedtls; ..\..\..\..\..\libraries\abstractions\pkcs11\include; ..\..\..\..\..\vendors\libre\mavid\components\LwIP\src\include\lwip; ..\..\..\..\..\demos\dev_mode_key_provisioning\include; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\include; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\test\access; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\src; ..\..\..\..\..\libraries\3rdparty\mbedtls\include; ..\..\..\..\..\libraries\3rdparty\mbedtls\include\mbedtls; ..\..\..\..\..\libraries\c_sdk\standard\https\include; ..\..\..\..\..\libraries\c_sdk\standard\https\src; ..\..\..\..\..\libraries\3rdparty\http_parser; ..\..\..\..\..\libraries\c_sdk\standard\https\test\access; ..\..\..\..\..\libraries\3rdparty\jsmn; ..\..\..\..\..\libraries\freertos_plus\aws\ota\include; ..\..\..\..\..\libraries\freertos_plus\aws\ota\src; ..\..\..\..\..\libraries\freertos_plus\aws\ota\test; ..\..\..\..\..\libraries\3rdparty\tinycbor; ..\..\..\..\..\demos\network_manager; ..\..\..\..\..\libraries\c_sdk\standard\common\include\types; ..\..\..\..\..\libraries\c_sdk\aws\shadow\include; ..\..\..\..\..\libraries\c_sdk\standard\serializer\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: UNITY_EXCLUDE_SETJMP_H; UNITY_EXCLUDE_MATH_H; UNITY_EXCLUDE_STDDEF_H; UNITY_EXCLUDE_STDINT_H; UNITY_OUTPUT_CHAR; UNITY_EXCLUDE_LIMITS_H; __ASSEMBLY__
  AARM.AUserIncludes: ..\..\..\..\..\vendors\libre\mavid\components\Inc; ..\..\..\..\..\libraries\3rdparty\unity\src; ..\..\..\..\..\vendors\libre\mavid\components\APP; ..\..\..\..\..\vendors\libre\boards\mavid\aws_tests\config_files
  OBJCOPY.OOCOutputFile: aws_demos.bin
  postbuild: PostProcess.bat  >  postprocesslogs.txt
  ILINK.IlinkOutputFile: aws_demos.out
  ILINK.IlinkIcfFile: stm32f769xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\vendors\libre\mavid\components\APP\lib\SDK.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application_code/libre_code
    ../../../../../demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
    ../../../../../vendors/libre/boards/mavid/aws_demos/application_code/: main.c
    ../../../../../vendors/libre/boards/mavid/aws_demos/application_code/libre_code/: mavid_hash.c startup_stm32f779xx.s stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c system_stm32f7xx.c
    ../../../../../vendors/libre/mavid/components/APP/lib/: os_port_freertos.c
  group config_files
    ../../../../../vendors/libre/boards/mavid/aws_demos/config_files/: aws_demo_config.h aws_wifi_config.h FreeRTOSConfig.h unity_config.h
  group demos
    ../../../../../demos/shadow/: aws_iot_demo_shadow.c
    ../../../../../demos/network_manager/: aws_iot_network_manager.c
    ../../../../../demos/tcp/: aws_tcp_echo_client_single_task.c
    ../../../../../demos/demo_runner/: iot_demo_freertos.c iot_demo_runner.c
    ../../../../../demos/mqtt/: iot_demo_mqtt.c
  group freertos_kernel
    ../../../../../vendors/libre/mavid/components/CMSIS_RTOS/: cmsis_os2.c
    ../../../../../freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos_kernel/include
    ../../../../../freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos_kernel/portable/IAR/ARM_CM7
    ../../../../../freertos_kernel/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group freertos_kernel/portable/MemMang
    ../../../../../freertos_kernel/portable/MemMang/: heap_4.c
  group libraries/3rdparty/mbedtls
    ../../../../../libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../../../../../vendors/libre/mavid/components/mbedTLS/port/: hardware_rng.c
    ../../../../../libraries/3rdparty/mbedtls/utils/: mbedtls_utils.c
  group libraries/3rdparty/unity/extras/fixture/src
    ../../../../../libraries/3rdparty/unity/extras/fixture/src/: unity_fixture.c
  group libraries/3rdparty/unity/src
    ../../../../../libraries/3rdparty/unity/src/: unity.c
  group libraries/adstractions/pkcs11/mbedtls
    ../../../../../libraries/abstractions/pkcs11/mbedtls/: iot_pkcs11_mbedtls.c
  group libraries/adstractions/platform
    ../../../../../libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_network_freertos.c iot_threads_freertos.c
  group libraries/c_sdk/aws/shadow/src
    ../../../../../libraries/c_sdk/aws/shadow/src/: aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_subscription.c
  group libraries/c_sdk/standard/common
    ../../../../../libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group libraries/c_sdk/standard/common/logging
    ../../../../../libraries/c_sdk/standard/common/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
  group libraries/c_sdk/standard/common/taskpool
    ../../../../../libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group libraries/c_sdk/standard/https/src
    ../../../../../libraries/c_sdk/standard/https/src/: iot_https_client.c iot_https_utils.c
  group libraries/c_sdk/standard/mqtt/src
    ../../../../../libraries/c_sdk/standard/mqtt/src/: iot_mqtt_agent.c iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_serialize.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_validate.c
  group libraries/c_sdk/standard/serializer
    ../../../../../libraries/c_sdk/standard/serializer/src/: iot_json_utils.c
  group libraries/freertos_plus/aws/ota/src
    ../../../../../libraries/freertos_plus/aws/ota/src/: aws_iot_ota_agent.c aws_iot_ota_interface.c
    ../../../../../libraries/freertos_plus/aws/ota/src/mqtt/: aws_iot_ota_cbor.c aws_iot_ota_mqtt.c
    ../../../../../libraries/freertos_plus/aws/ota/src/http/: aws_iot_ota_http.c
  group libraries/freertos_plus/aws/ota/test
    ../../../../../libraries/freertos_plus/aws/ota/test/: aws_test_ota_agent.c aws_test_ota_pal.c
  group libraries/freertos_plus/standard/crypto
    ../../../../../libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group libraries/freertos_plus/standard/pkcs11
    ../../../../../libraries/freertos_plus/standard/pkcs11/src/: iot_pkcs11.c
  group libraries/freertos_plus/standard/tls/src
    ../../../../../libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group libraries/freertos_plus/standard/tls/test
    ../../../../../libraries/freertos_plus/standard/tls/test/: iot_test_tls.c
  group libraries/freertos_plus/standard/utils
    ../../../../../libraries/freertos_plus/standard/utils/src/: iot_pki_utils.c
  group lwip
    ../../../../../vendors/libre/mavid/components/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../vendors/libre/mavid/components/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../../../../../vendors/libre/mavid/components/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../vendors/libre/mavid/components/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../vendors/libre/mavid/components/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../vendors/libre/mavid/components/LwIP/src/apps/dhcpserver/: dhcp_server.c
    ../../../../../vendors/libre/mavid/components/LwIP/src/netif/: ethernet.c ethernetif_template.c lowpan6.c slipif.c
    ../../../../../vendors/libre/mavid/components/LwIP/src/apps/lwiperf/: lwiperf.c
    ../../../../../vendors/libre/mavid/components/LwIP/src/apps/mdns/: mdns.c
    ../../../../../vendors/libre/mavid/components/LwIP/src/apps/netbiosns/: netbiosns.c
    ../../../../../vendors/libre/mavid/components/LwIP/src/apps/ping/: ping.c
    ../../../../../vendors/libre/mavid/components/LwIP/src/apps/snmp/: snmp_asn1.c snmp_core.c snmp_mib2.c snmp_mib2_icmp.c snmp_mib2_interfaces.c snmp_mib2_ip.c snmp_mib2_snmp.c snmp_mib2_system.c snmp_mib2_tcp.c snmp_mib2_udp.c snmp_msg.c snmp_netconn.c snmp_pbuf_stream.c snmp_raw.c snmp_scalar.c snmp_table.c snmp_threadsync.c snmp_traps.c snmpv3.c snmpv3_dummy.c snmpv3_mbedtls.c
    ../../../../../vendors/libre/mavid/components/LwIP/src/apps/sntp/: sntp.c
    ../../../../../vendors/libre/mavid/components/LwIP/system/OS/: sys_arch.c
  group lzma
    ../../../../../vendors/libre/mavid/components/lzma/: 7zFile.c 7zStream.c Alloc.c LzFind.c LzmaDec.c LzmaEnc.c
  group vendors/libre/boards/mavid/ports/mbedTLS
    ../../../../../vendors/libre/boards/mavid/ports/mbedTLS/: hardware_rng.c
  group vendors/libre/boards/mavid/ports/pkcs11
    ../../../../../vendors/libre/boards/mavid/ports/pkcs11/: iot_pkcs11_pal.c
  group vendors/libre/boards/mavid/ports/secure_sockets
    ../../../../../vendors/libre/boards/mavid/ports/secure_sockets/: iot_secure_sockets.c
  group vendors/libre/boards/mavid/ports/wifi
    ../../../../../vendors/libre/boards/mavid/ports/wifi/: iot_wifi.c
  group vendors/libre/mavid/BSP
    ../../../../../vendors/libre/mavid/BSP/STM32F769I_EVAL/: bsp_uart.c stm32f769i_eval.c stm32f769i_eval_io.c stm32f769i_eval_sd.c stm32f769i_eval_sdram_mavid.c
  group vendors/libre/mavid/HAL_DRIVER
    ../../../../../vendors/libre/mavid/HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_mmc.c stm32f7xx_hal_msp.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_smbus.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_adc.c stm32f7xx_ll_crc.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_exti.c stm32f7xx_ll_fmc.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_lptim.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rng.c stm32f7xx_ll_rtc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c stm32f7xx_ll_usb.c stm32f7xx_ll_utils.c
